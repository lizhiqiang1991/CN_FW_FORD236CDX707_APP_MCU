# IAR project cm4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ${IAR_DEVICE_NAME}_M4 Infineon ${IAR_DEVICE_NAME}_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../: ${ARG_EXE_NAME_CM4}${CMAKE_EXECUTABLE_SUFFIX}
