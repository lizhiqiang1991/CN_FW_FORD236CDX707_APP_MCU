# IAR project cm0plus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ${IAR_DEVICE_NAME}_M0+ Infineon ${IAR_DEVICE_NAME}_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../: ${ARG_EXE_NAME_CM0PLUS}${CMAKE_EXECUTABLE_SUFFIX}
