# IAR project cm7_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ${IAR_DEVICE_NAME}_M7 Infineon ${IAR_DEVICE_NAME}_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../: ${ARG_EXE_NAME_CM7_1}${CMAKE_EXECUTABLE_SUFFIX}
